# IAR project ecode.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F103xE
  ICCARM.CCIncludePath2: ..\..\..\applications; ..\..\..\drivers; ..\..\..\kernel; ..\..\..\library\FreeRTOSv9.0.0\FreeRTOS\Source\include; ..\..\..\library\FreeRTOSv9.0.0\FreeRTOS\Source\portable\IAR\ARM_CM3; ..\..\..\library\platform\STM32Cube_FW_F1_V1.6.1\CMSIS\Include; ..\..\..\library\platform\STM32Cube_FW_F1_V1.6.1\CMSIS\Device\ST\STM32F1xx\Include; ..\..\..\library\platform\STM32Cube_FW_F1_V1.6.1\STM32F1xx_HAL_Driver\Inc; ..\..\..\misc; ..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\library\FreeRTOSv9.0.0\FreeRTOS\Source\portable\IAR\ARM_CM3; ..
  OBJCOPY.OOCOutputFile: ecode.srec
  ILINK.IlinkOutputFile: ecode.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  group applications/cli
    ../../../applications/cli/: cli_lexer.c cli_parser.c cli_server.c cli_string.c
  group arch
    ../../../arch/: plat.c
  group drivers/serial
    ../../../drivers/serial/: serial.c
  group global
    ../../../global/: include.h startup.c
  group kernel
    ../../../kernel/: cmsis_os.c device.c kernel.c klist.c kmem.c ktime.c print.c
  group library/FreeRTOS
    ../../../library/FreeRTOSv9.0.0/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c readme.txt tasks.c timers.c
  group library/FreeRTOS/portable
    ../../../library/FreeRTOSv9.0.0/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../library/FreeRTOSv9.0.0/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s portmacro.h
  group library/STM32Cube_FW_F1_V1.6.1/CMSIS
    ../../../library/platform/STM32Cube_FW_F1_V1.6.1/CMSIS/Device/ST/STM32F1xx/Source/Templates/iar/: startup_stm32f103xe.s
    ../../../library/platform/STM32Cube_FW_F1_V1.6.1/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group library/STM32Cube_FW_F1_V1.6.1/plat
    ../../../library/platform/STM32Cube_FW_F1_V1.6.1/plat/: plat-stm32f1xx.c
  group library/STM32Cube_FW_F1_V1.6.1/STM32F1xx_HAL_Driver
    ../../../library/platform/STM32Cube_FW_F1_V1.6.1/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_mmc.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_adc.c stm32f1xx_ll_crc.c stm32f1xx_ll_dac.c stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_gpio.c stm32f1xx_ll_i2c.c stm32f1xx_ll_pwr.c stm32f1xx_ll_rcc.c stm32f1xx_ll_rtc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_spi.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c stm32f1xx_ll_usb.c stm32f1xx_ll_utils.c
  group misc
    ../../../misc/: crc16.c crc8.c fifo.c pid.c
  group user
    ../: application.c driver.c FreeRTOSConfig.h kconfig.h stm32f1xx_hal_conf.h stm32f1xx_it.c stm32f1xx_it.h
  group user/application
    ../application/: handle.c led_server.c serial_console.c version.c
  group user/driver
    ../driver/: drv_led.c drv_uart.c
