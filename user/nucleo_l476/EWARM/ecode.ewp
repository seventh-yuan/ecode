# IAR project ecode.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L476xx
  ICCARM.CCIncludePath2: ..\..\..\applications; ..\..\..\drivers; ..\..\..\library\FreeRTOSv9.0.0\FreeRTOS\Source\include; ..\..\..\library\FreeRTOSv9.0.0\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\library\platform\STM32Cube_FW_L4_V1.11.0\CMSIS\Include; ..\..\..\library\platform\STM32Cube_FW_L4_V1.11.0\STM32L4xx_HAL_Driver\Inc; ..\..\..\misc; ..; ..\..\..\library\platform\STM32Cube_FW_L4_V1.11.0\CMSIS\Device\ST\STM32L4xx\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: ecode.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group applications/cli
    ../../../applications/cli/: cli_lexer.c cli_parser.c cli_server.c cli_string.c
  group arch
    ../../../arch/: plat.c
  group drivers/serial
    ../../../drivers/serial/: serial.c
  group global
    ../../../global/: include.h startup.c syscfg.h types.h
  group kernel
    ../../../kernel/: cmsis_os.c device.c kernel.c klist.c kmem.c ktime.c print.c
  group library/FreeRTOSv9.0.0
    ../../../library/FreeRTOSv9.0.0/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group library/FreeRTOSv9.0.0/portable
    ../../../library/FreeRTOSv9.0.0/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../library/FreeRTOSv9.0.0/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group library/STM32Cube_FW_L4_V1.11.0/CMSIS
    ../../../library/platform/STM32Cube_FW_L4_V1.11.0/CMSIS/Device/ST/STM32L4xx/Source/Templates/iar/: startup_stm32l476xx.s
    ../../../library/platform/STM32Cube_FW_L4_V1.11.0/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group library/STM32Cube_FW_L4_V1.11.0/plat
    ../../../library/platform/STM32Cube_FW_L4_V1.11.0/plat/: plat-stm32l4xx.c
  group library/STM32Cube_FW_L4_V1.11.0/STM32L4xx_HAL_Driver
    ../../../library/platform/STM32Cube_FW_L4_V1.11.0/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_can.c stm32l4xx_hal_comp.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dcmi.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma2d.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_dsi.c stm32l4xx_hal_firewall.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gfxmmu.c stm32l4xx_hal_gpio.c stm32l4xx_hal_hash.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal_hcd.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_irda.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_lcd.c stm32l4xx_hal_lptim.c stm32l4xx_hal_ltdc.c stm32l4xx_hal_ltdc_ex.c stm32l4xx_hal_nand.c stm32l4xx_hal_nor.c stm32l4xx_hal_opamp.c stm32l4xx_hal_opamp_ex.c stm32l4xx_hal_ospi.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_sai_ex.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_smartcard.c stm32l4xx_hal_smartcard_ex.c stm32l4xx_hal_smbus.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_sram.c stm32l4xx_hal_swpmi.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_tsc.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_wwdg.c stm32l4xx_ll_adc.c stm32l4xx_ll_comp.c stm32l4xx_ll_crc.c stm32l4xx_ll_crs.c stm32l4xx_ll_dac.c stm32l4xx_ll_dma.c stm32l4xx_ll_dma2d.c stm32l4xx_ll_exti.c stm32l4xx_ll_fmc.c stm32l4xx_ll_gpio.c stm32l4xx_ll_i2c.c stm32l4xx_ll_lptim.c stm32l4xx_ll_lpuart.c stm32l4xx_ll_opamp.c stm32l4xx_ll_pwr.c stm32l4xx_ll_rcc.c stm32l4xx_ll_rng.c stm32l4xx_ll_rtc.c stm32l4xx_ll_sdmmc.c stm32l4xx_ll_spi.c stm32l4xx_ll_swpmi.c stm32l4xx_ll_tim.c stm32l4xx_ll_usart.c stm32l4xx_ll_usb.c stm32l4xx_ll_utils.c
  group misc
    ../../../misc/: crc16.c crc8.c fifo.c pid.c
  group user
    ../: application.c driver.c FreeRTOSConfig.h kconfig.h stm32l4xx_hal_conf.h stm32l4xx_hal_msp.c stm32l4xx_it.c
  group user/application
    ../application/: handle.c led_server.c serial_console.c version.c
  group user/driver
    ../driver/: drv_led.c drv_uart.c
