# IAR project ecode.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303RE ST STM32F303RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F303xE
  ICCARM.CCIncludePath2: ..\..\..\library\FreeRTOSv9.0.0\FreeRTOS\Source\include; ..\..\..\library\FreeRTOSv9.0.0\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\library\platform\STM32Cube_FW_F3_V1.9.0\CMSIS\Device\ST\STM32F3xx\Include; ..\..\..\library\platform\STM32Cube_FW_F3_V1.9.0\CMSIS\Include; ..\..\..\library\platform\STM32Cube_FW_F3_V1.9.0\STM32F3xx_HAL_Driver\Inc; ..; ..\driver; ..\..\..\applications; ..\..\..\drivers
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\library\FreeRTOSv9.0.0\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\
  ILINK.IlinkOutputFile: ecode.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f303xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group applications/cli
    ../../../applications/cli/: cli_lexer.c cli_parser.c cli_server.c cli_string.c
  group applications/xmodem
    ../../../applications/xmodem/: xmodem.c
  group arch
    ../../../arch/: plat.c
  group drivers/serial
    ../../../drivers/serial/: serial.c
  group global
    ../../../global/: include.h startup.c syscfg.h types.h
  group kernel
    ../../../kernel/: cmsis_os.c device.c kernel.c klist.c kmem.c ktime.c print.c
  group library/FreeRTOSv9.0.0/Source
    ../../../library/FreeRTOSv9.0.0/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group library/FreeRTOSv9.0.0/Source/portable
    ../../../library/FreeRTOSv9.0.0/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../library/FreeRTOSv9.0.0/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group library/platform/STM32Cube_FW_F3_V1.9.0/CMSIS
    ../../../library/platform/STM32Cube_FW_F3_V1.9.0/CMSIS/Device/ST/STM32F3xx/Source/Templates/iar/: startup_stm32f303xe.s
    ../../../library/platform/STM32Cube_FW_F3_V1.9.0/CMSIS/Device/ST/STM32F3xx/Source/Templates/: system_stm32f3xx.c
  group library/platform/STM32Cube_FW_F3_V1.9.0/plat
    ../../../library/platform/STM32Cube_FW_F3_V1.9.0/plat/: plat-stm32f3xx.c
  group library/platform/STM32Cube_FW_F3_V1.9.0/STM32F3xx_HAL_Driver
    ../../../library/platform/STM32Cube_FW_F3_V1.9.0/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_can.c stm32f3xx_hal_cec.c stm32f3xx_hal_comp.c stm32f3xx_hal_cortex.c stm32f3xx_hal_crc.c stm32f3xx_hal_crc_ex.c stm32f3xx_hal_dac.c stm32f3xx_hal_dac_ex.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_hrtim.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_i2s.c stm32f3xx_hal_i2s_ex.c stm32f3xx_hal_irda.c stm32f3xx_hal_iwdg.c stm32f3xx_hal_nand.c stm32f3xx_hal_nor.c stm32f3xx_hal_opamp.c stm32f3xx_hal_opamp_ex.c stm32f3xx_hal_pccard.c stm32f3xx_hal_pcd.c stm32f3xx_hal_pcd_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_rtc.c stm32f3xx_hal_rtc_ex.c stm32f3xx_hal_sdadc.c stm32f3xx_hal_smartcard.c stm32f3xx_hal_smartcard_ex.c stm32f3xx_hal_smbus.c stm32f3xx_hal_spi.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal_sram.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_tsc.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_usart.c stm32f3xx_hal_wwdg.c stm32f3xx_ll_adc.c stm32f3xx_ll_comp.c stm32f3xx_ll_crc.c stm32f3xx_ll_dac.c stm32f3xx_ll_dma.c stm32f3xx_ll_exti.c stm32f3xx_ll_fmc.c stm32f3xx_ll_gpio.c stm32f3xx_ll_hrtim.c stm32f3xx_ll_i2c.c stm32f3xx_ll_opamp.c stm32f3xx_ll_pwr.c stm32f3xx_ll_rcc.c stm32f3xx_ll_rtc.c stm32f3xx_ll_spi.c stm32f3xx_ll_tim.c stm32f3xx_ll_usart.c stm32f3xx_ll_utils.c
  group misc
    ../../../misc/: crc16.c crc8.c fifo.c pid.c
  group user
    ../: application.c driver.c FreeRTOSConfig.h kconfig.h stm32f3xx_hal_conf.h stm32f3xx_hal_msp.c stm32f3xx_it.c stm32f3xx_it.h
  group user/application
    ../application/: handle.c led_server.c serial_console.c version.c
  group user/driver
    ../driver/: drv_led.c drv_uart.c
